# Keil uVision project 06_01_RTC_Calendar_Register.uvprojx, settings and files
target Target_1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 06_01_RTC_Calendar_Register +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\Start;.\User;.\User\Com;.\User\Dri;.\User\Int
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Start
    ./Start/: core_cm3.c core_cm3.h startup_stm32f10x_hd.s stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group User/Com
    ./User/Com/: Com_Util.c
  group User/Dri
    ./User/Dri/: Dri_USART1.c Dri_I2C.c Dri_I2C2.c Dri_SysTick.c Dri_TIM6.c Dri_TIM5.c Dri_TIM4.c Dri_TIM1.c Dri_DMA.c Dri_ADC1.c Dri_SPI.c Dri_LowPower.c Dri_RTC.c
  group User/Int
    ./User/Int/: Int_LED.c Int_Key.c Int_EEPROM.c Int_NorFlash.c
  group User
    ./User/: main.c
